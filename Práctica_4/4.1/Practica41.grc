options:
  parameters:
    author: Ashely_Amaya_Otto_Andrade_J1C_G3
    copyright: UIS
    generate_options: qt_gui
    id: Practica41
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: 'Frecuencia mensaje '
    start: '0'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Kp
    start: '0'
    step: '0.000001'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: Practica441_0
  id: Practica441
  parameters:
    Ac: Ac
    Kp: Kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Practica441_0, '0', blocks_complex_to_mag_0, '0']
- [Practica441_0, '0', qtgui_freq_sink_x_0, '0']
- [Practica441_0, '0', qtgui_time_sink_x_0, '0']
- [Practica441_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Practica441_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
