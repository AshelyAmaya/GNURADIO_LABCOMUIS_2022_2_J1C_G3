options:
  parameters:
    author: Ashely_Amaya_Otto_Andrade_J1C_G3
    copyright: UIS
    generate_options: qt_gui
    id: ModulacionAM
    output_language: python
    title: Modulador de Amplitud
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '25'
  states: {}
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del receptor
    rangeType: int
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la Portadora
    start: 88e6
    step: 1e5
    stop: 108e6
    value: 90.7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6250000'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: int(samp_rate/D)
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: int(samp_rate/D)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: int(D)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    fc: fc
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/D)
    interp: '44100'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_preemph_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_preemph_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
