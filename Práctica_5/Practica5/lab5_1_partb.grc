options:
  parameters:
    author: Ashely_Amaya_Otto_Andrade_J1C_G3
    copyright: UIS
    generate_options: qt_gui
    id: MultiplexaPAM
    output_language: python
    title: MultiplexaPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Retardo 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: Retardo 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Retardo 3
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: D5
  id: variable_qtgui_range
  parameters:
    label: Retardo 5
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {state: disabled}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ModuladorPAM_0
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_1
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_1_0
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_1_0_0
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_1_0_1
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_1_0_2
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_2
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModuladorPAM_3
  id: ModuladorPAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 100-0
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_3
  id: blocks_delay
  parameters:
    delay: 100-D1
    type: float
  states: {}
- name: blocks_delay_4
  id: blocks_delay
  parameters:
    delay: 100-D2
    type: float
  states: {}
- name: blocks_delay_5
  id: blocks_delay
  parameters:
    delay: 100-D3
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [ModuladorPAM_0, '0', blocks_delay_0, '0']
- [ModuladorPAM_1, '0', blocks_add_xx_0, '0']
- [ModuladorPAM_1, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPAM_1_0, '0', blocks_float_to_complex_0, '0']
- [ModuladorPAM_1_0, '0', qtgui_time_sink_x_2, '0']
- [ModuladorPAM_1_0_0, '0', qtgui_time_sink_x_2, '1']
- [ModuladorPAM_1_0_1, '0', qtgui_time_sink_x_2, '2']
- [ModuladorPAM_1_0_2, '0', qtgui_time_sink_x_2, '3']
- [ModuladorPAM_2, '0', blocks_delay_2, '0']
- [ModuladorPAM_3, '0', blocks_delay_1, '0']
- [analog_sig_source_x_0, '0', ModuladorPAM_1, '0']
- [analog_sig_source_x_1, '0', ModuladorPAM_0, '0']
- [analog_sig_source_x_2, '0', ModuladorPAM_2, '0']
- [analog_sig_source_x_3, '0', ModuladorPAM_3, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_3, '0']
- [blocks_add_xx_0, '0', blocks_delay_4, '0']
- [blocks_add_xx_0, '0', blocks_delay_5, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', ModuladorPAM_1_0, '0']
- [blocks_delay_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_2, '0', blocks_add_xx_0, '2']
- [blocks_delay_2, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_3, '0', ModuladorPAM_1_0_0, '0']
- [blocks_delay_4, '0', ModuladorPAM_1_0_1, '0']
- [blocks_delay_5, '0', ModuladorPAM_1_0_2, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
