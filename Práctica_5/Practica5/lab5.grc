options:
  parameters:
    author: Ashely_Amaya_Otto_Andrade_J1C_G3
    copyright: UIS
    generate_options: qt_gui
    id: PruebaPAM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: Modulador_PAM_0
  id: Modulador_PAM
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulador_PAM_0, '0', blocks_float_to_complex_0, '0']
- [Modulador_PAM_0, '0', qtgui_freq_sink_x_0, '0']
- [Modulador_PAM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', Modulador_PAM_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
